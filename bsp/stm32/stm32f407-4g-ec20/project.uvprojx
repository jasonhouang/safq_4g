# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F407xx, RT_USING_ARM_LIBC
  c include: .;..\..\..\include;applications;.;board;board\CubeMX_Config\Inc;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;packages\ali-iotkit\iotkit-embedded\src\infra;packages\ali-iotkit\iotkit-embedded\src\mqtt\impl;packages\ali-iotkit\iotkit-embedded\src\mqtt;packages\ali-iotkit\iotkit-embedded\src\dev_model;packages\ali-iotkit\iotkit-embedded\src\dev_model\client;packages\ali-iotkit\iotkit-embedded\src\dev_model\server;packages\ali-iotkit\iotkit-embedded\src\dev_sign;packages\ali-iotkit\iotkit-embedded\src\ota;packages\ali-iotkit\iotkit-embedded\wrappers;packages\ali-iotkit\iotkit-embedded\samples\dev_model;packages\ali-iotkit-latest\iotkit-embedded\src\infra;packages\ali-iotkit-latest\iotkit-embedded\src\mqtt\impl;packages\ali-iotkit-latest\iotkit-embedded\src\mqtt;packages\ali-iotkit-latest\iotkit-embedded\src\dev_model;packages\ali-iotkit-latest\iotkit-embedded\src\dev_model\client;packages\ali-iotkit-latest\iotkit-embedded\src\dev_model\server;packages\ali-iotkit-latest\iotkit-embedded\src\dev_sign;packages\ali-iotkit-latest\iotkit-embedded\src\ota;packages\ali-iotkit-latest\iotkit-embedded\wrappers;packages\ali-iotkit-latest\iotkit-embedded\samples\dev_model;packages\cJSON-v1.0.2;packages\mbedtls-v2.7.10\mbedtls\include;packages\mbedtls-v2.7.10\ports\inc;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\..\..\components\net\at\include;..\..\..\components\net\at\at_socket;..\..\..\components\net\netdev\include;..\..\..\components\net\sal_socket\include;..\..\..\components\net\sal_socket\include\socket;..\..\..\components\net\sal_socket\impl;..\..\..\components\net\sal_socket\include\dfs_net;..\..\..\components\net\sal_socket\include\dfs_net\sys_select;..\..\..\components\net\sal_socket\include\socket\sys_socket;..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\libraries\STM32F4xx_HAL\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group ali-iotkit
    packages/ali-iotkit/iotkit-embedded/src/infra/: infra_defs.c infra_cjson.c infra_compat.c infra_httpc.c infra_json_parser.c infra_log.c infra_md5.c infra_net.c infra_prt_nwk_payload.c infra_report.c infra_sha256.c infra_string.c infra_timer.c
    packages/ali-iotkit/iotkit-embedded/src/mqtt/: mqtt_api.c
    packages/ali-iotkit/iotkit-embedded/src/mqtt/impl/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c iotx_mqtt_client.c
    packages/ali-iotkit/iotkit-embedded/src/dev_model/client/: dm_client.c dm_client_adapter.c
    packages/ali-iotkit/iotkit-embedded/src/dev_model/: dm_api.c dm_cota.c dm_fota.c dm_ipc.c dm_manager.c dm_message_cache.c dm_message.c dm_opt.c dm_ota.c dm_msg_process.c dm_utils.c iotx_cm_mqtt.c impl_linkkit.c iotx_cm.c dm_log_report.c
    packages/ali-iotkit/iotkit-embedded/src/dev_sign/: dev_sign_mqtt.c
    packages/ali-iotkit/iotkit-embedded/src/ota/: iotx_ota.c ota_fetch.c ota_lib.c
    packages/ali-iotkit/ports/rtthread/: HAL_OS_rtthread.c HAL_TCP_rtthread.c HAL_UDP_rtthread.c
    packages/ali-iotkit/ports/: wrapper.c
    packages/ali-iotkit/iotkit-embedded/certs/: root_ca.c
    packages/ali-iotkit/ports/tls/mbedtls/: HAL_TLS_mbedtls.c
    packages/ali-iotkit/samples/dev_model/: cJSON.c linkkit_example_solo.c
    packages/ali-iotkit/samples/mqtt/: mqtt-example.c
    packages/ali-iotkit-latest/iotkit-embedded/src/infra/: infra_defs.c infra_cjson.c infra_compat.c infra_httpc.c infra_json_parser.c infra_log.c infra_md5.c infra_net.c infra_prt_nwk_payload.c infra_report.c infra_sha256.c infra_string.c infra_timer.c
    packages/ali-iotkit-latest/iotkit-embedded/src/mqtt/: mqtt_api.c
    packages/ali-iotkit-latest/iotkit-embedded/src/mqtt/impl/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c iotx_mqtt_client.c
    packages/ali-iotkit-latest/iotkit-embedded/src/dev_model/client/: dm_client.c dm_client_adapter.c
    packages/ali-iotkit-latest/iotkit-embedded/src/dev_model/: dm_api.c dm_cota.c dm_fota.c dm_ipc.c dm_manager.c dm_message_cache.c dm_message.c dm_opt.c dm_ota.c dm_msg_process.c dm_utils.c iotx_cm_mqtt.c impl_linkkit.c iotx_cm.c dm_log_report.c
    packages/ali-iotkit-latest/iotkit-embedded/src/dev_sign/: dev_sign_mqtt.c
    packages/ali-iotkit-latest/iotkit-embedded/src/ota/: iotx_ota.c ota_fetch.c ota_lib.c
    packages/ali-iotkit-latest/ports/rtthread/: HAL_OS_rtthread.c HAL_TCP_rtthread.c HAL_UDP_rtthread.c
    packages/ali-iotkit-latest/ports/: wrapper.c
    packages/ali-iotkit-latest/iotkit-embedded/certs/: root_ca.c
    packages/ali-iotkit-latest/ports/tls/mbedtls/: HAL_TLS_mbedtls.c
    packages/ali-iotkit-latest/samples/dev_model/: linkkit_example_solo.c
    packages/ali-iotkit-latest/samples/mqtt/: mqtt-example.c
  group cJSON
    packages/cJSON-v1.0.2/: cJSON.c cJSON_port.c cJSON_util.c
  group mbedtls
    packages/mbedtls-v2.7.10/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    packages/mbedtls-v2.7.10/ports/src/: aes_alt.c arc4_alt.c des_alt.c md5_alt.c rsa_alt.c sha1_alt.c sha256_alt.c sha512_alt.c timing_alt.c tls_certificate.c tls_client.c tls_hardware.c tls_net.c
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group Filesystem
    ../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../../components/finsh/: shell.c cmd.c msh.c msh_file.c
  group libc
    ../../../components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    ../../../components/libc/compilers/common/: time.c
  group AT
    ../../../components/net/at/src/: at_utils.c at_cli.c at_client.c
    ../../../components/net/at/at_socket/: at_socket.c
  group netdev
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    ../../../components/net/sal_socket/src/: sal_socket.c
    ../../../components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal_socket/impl/: af_inet_at.c proto_mbedtls.c
    ../../../components/net/sal_socket/dfs_net/: dfs_net.c
  group STM32_HAL
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c
